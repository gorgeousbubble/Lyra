# IAR project lyra.ewp, settings and files
configuration MK64FN1M0(Debug) (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 NXP MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; ARM_MATH_CM4; MK64F12; MK64FN1M0
  ICCARM.CCIncludePath2: ..\..\app\inc; ..\..\board\inc; ..\..\chip\inc; ..\..\dev\inc; ..\..\lib\CMSIS\inc; ..\..\lib\FatFs; ..\..\lib\USB\inc; ..\..\startup\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: lyra.hex
  ILINK.IlinkOutputFile: lyra.out
  ILINK.IlinkIcfFile: config files\MK64FN1M0_FLASH.icf
  ILINK.IlinkAdditionalLibs: ..\..\lib\CMSIS\iar_cortexM4lf_math.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration MK64FN1M0(Release) (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
configuration MK64FX512(Debug) (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
configuration MK64FX512(Release) (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  group app
    ../../app/src/: main.c
  group inc
    ../../chip/inc/: common.h
    ../../startup/inc/: misc.h MK64F12.h system_init.h vectors.h
  group lib/cmsis
    ../../lib/CMSIS/inc/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h core_sc000.h core_sc300.h
  group lib/fatfs
    ../../lib/FatFs/: diskio.c diskio.h ff.c ff.h ffconf.h integer.h readme.txt
  group lib/fatfs/option
    ../../lib/FatFs/option/: cc932.c cc936.c cc949.c cc950.c ccsbcs.c syscall.c
  group lib/usb
    ../../lib/USB/inc/: FSL_Types.h USB.h USB_CDC.h USB_Desc.h
    ../../lib/USB/src/: USB.c USB_CDC.c
  group prj
    config files/: MK64FN1M0_FLASH.icf MK64FN1M0_RAM.icf MK64FX512_FLASH.icf MK64FX512_RAM.icf
  group startup
    ../../startup/src/: misc.c startup.s system_init.c vectors.c
